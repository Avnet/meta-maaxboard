PLATFORM_FLAVOR_maaxboard   = "mx8mqevk"
PLATFORM_FLAVOR_maaxboardmini   = "mx8mmevk"
PLATFORM_FLAVOR_maaxboardnano   = "mx8mnevk"