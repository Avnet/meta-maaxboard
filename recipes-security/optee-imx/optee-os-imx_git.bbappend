PLATFORM_FLAVOR_maaxboard   = "mx8mqevk"