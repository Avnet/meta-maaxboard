SRC_URI = "${FSL_MIRROR}/firmware-imx-8.0.1.bin;fsl-eula=true"

SRC_URI[md5sum] = "82d17491184f491b7c2fe6ed3a787c2f"
SRC_URI[sha256sum] = "0b3bec6f2796608647f0c982bfce11f54d2534bb3474ef3e33e7c7f50d419abb"