
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
        file://chromium-wayland/0016-Only-DRI-for-x11.patch \
"
