DUMMYPROVIDES_PACKAGES_remove_maaxboard = " \
    bash \
"