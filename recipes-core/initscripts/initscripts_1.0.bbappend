
MASKED_SCRIPTS += " \
  umountfs \
  rc.local \
  umountnfs \
  reboot \
  save-rtc \
  single \
  halt \
  sendsigs \
"
