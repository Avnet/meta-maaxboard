require recipes-kernel/linux/linux-maaxboard-src.inc
