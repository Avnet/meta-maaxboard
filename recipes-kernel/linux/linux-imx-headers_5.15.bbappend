require recipes-kernel/linux/linux-maaxboard-src-5.15.inc