require recipes-kernel/linux/linux-maaxboard-src-${PV}.inc