require recipes-kernel/linux/linux-maaxboard-mini-src-base-${PV}.inc
